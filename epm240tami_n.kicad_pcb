# Repository udif/epm240tami

File README.md:

EPM240TAMI

This board is intended to connect one EPM240 CPLD to the ATTAMI board, or to be used as a standalone board.
It includes a standard JTAG connector, a DC barrel connector, full I/O breakout, selectable voltage for VCCIO1/2,
and a socket for the ATTAMI board.

## KiCad design epm240tami_n.kicad_pcb

Parts:
C1, C2: CP1; C_0603
C3, C4, C5, C6, C7, C8, C9, C10: C; C_0603
CON1: AB2_POWER_BARREL; AB2_PB_2MM_JACK_PTH
P1, P3: CONN_01X02; Pin_Header_Straight_1x02
P2: CONN_01X02; Socket_Strip_Straight_1x02
P4, P5: CONN_02X22; Pin_Header_Straight_2x22
P6: JTAG; Pin_Header_Straight_2x05
P7: CONN_01X07; Socket_Strip_Straight_1x07
R1: 1K; R_0805
R2, R3, R4: 10K; R_0805
U1: EPM240T100C5N; TQFP-100_14x14mm_Pitch0.5mm
U2: AMS1117-3.3V; SOT-223
X1: 50MHz; crystal_HXO-3

Connections:
/CLK_CORE: P4.24, U1.12 (IO/GCLK0), X1.3 (OUT)
/DI: P4.41, P7.2, U1.88 (IO)
/DM: P4.29, P7.5, U1.2 (IO)
/DO: P4.42, P7.3, U1.89 (IO)
/DP1: P4.30, P7.6, U1.3 (IO)
/DP2: P4.27, P7.7, U1.4 (IO)
/IO1: P4.32, U1.1 (IO)
/IO5: P4.28, U1.5 (IO)
/IO6: P4.25, U1.6 (IO)
/IO7: P4.26, U1.7 (IO)
/IO8: P4.23, U1.8 (IO)
/IO14: P4.21, U1.14 (IO/GCLK1)
/IO15: P4.22, U1.15 (IO)
/IO16: P4.20, U1.16 (IO)
/IO17: P4.19, U1.17 (IO)
/IO18: P4.18, U1.18 (IO)
/IO19: P4.17, U1.19 (IO)
/IO20: P4.16, U1.20 (IO)
/IO21: P4.15, U1.21 (IO)
/IO26: P4.14, U1.26 (IO)
/IO27: P4.13, U1.27 (IO)
/IO28: P4.12, U1.28 (IO)
/IO29: P4.11, U1.29 (IO)
/IO30: P4.10, U1.30 (IO)
/IO33: P4.9, U1.33 (IO)
/IO34: P4.8, U1.34 (IO)
/IO35: P4.7, U1.35 (IO)
/IO36: P4.6, U1.36 (IO)
/IO37: P4.5, U1.37 (IO)
/IO38: P4.4, U1.38 (IO)
/IO39: P4.3, U1.39 (IO)
/IO40: P5.4, U1.40 (IO)
/IO41: P5.3, U1.41 (IO)
/IO42: P5.6, U1.42 (IO)
/IO43: P5.5, U1.43 (IO/DEV_OE)
/IO44: P5.8, U1.44 (IO/DEV_CLRn)
/IO47: P5.7, U1.47 (IO)
/IO48: P5.10, U1.48 (IO)
/IO49: P5.9, U1.49 (IO)
/IO50: P5.12, U1.50 (IO)
/IO51: P5.11, U1.51 (IO)
/IO52: P5.14, U1.52 (IO)
/IO53: P5.13, U1.53 (IO)
/IO54: P5.16, U1.54 (IO)
/IO55: P5.15, U1.55 (IO)
/IO56: P5.18, U1.56 (IO)
/IO57: P5.17, U1.57 (IO)
/IO58: P5.19, U1.58 (IO)
/IO61: P5.20, U1.61 (IO)
/IO62: P5.21, P7.4, U1.62 (IO/GCLK2)
/IO64: P5.22, U1.64 (IO/GCLK3)
/IO66: P5.23, U1.66 (IO)
/IO67: P5.24, U1.67 (IO)
/IO68: P5.25, U1.68 (IO)
/IO69: P5.26, U1.69 (IO)
/IO70: P5.27, U1.70 (IO)
/IO71: P5.28, U1.71 (IO)
/IO72: P5.29, U1.72 (IO)
/IO73: P5.30, U1.73 (IO)
/IO74: P5.31, U1.74 (IO)
/IO75: P5.32, U1.75 (IO)
/IO76: P5.33, U1.76 (IO)
/IO77: P5.34, U1.77 (IO)
/IO78: P5.35, U1.78 (IO)
/IO81: P5.36, U1.81 (IO)
/IO82: P5.37, U1.82 (IO)
/IO83: P5.38, U1.83 (IO)
/IO84: P5.39, U1.84 (IO)
/IO85: P5.40, U1.85 (IO)
/IO86: P5.41, U1.86 (IO)
/IO87: P5.42, U1.87 (IO)
/IO90: P4.39, U1.90 (IO)
/IO91: P4.40, U1.91 (IO)
/IO92: P4.37, U1.92 (IO)
/IO95: P4.38, U1.95 (IO)
/IO96: P4.35, U1.96 (IO)
/IO97: P4.36, U1.97 (IO)
/IO98: P4.33, U1.98 (IO)
/IO99: P4.34, U1.99 (IO)
/IO100: P4.31, U1.100 (IO)
/TCK: P6.1, R1.1 (A), U1.24 (TCK)
/TDI: P6.9, R2.2 (K), U1.23 (TDI)
/TDO: P6.3, R4.2 (K), U1.25 (TDO)
/TMS: P6.5, R3.2 (K), U1.22 (TMS)
/VCCIO1: C5.1, C6.1, C7.1, P1.1, U1.9 (VCCIO1), U1.31 (VCCIO1), U1.45 (VCCIO1)
/VCCIO2: C8.1, C9.1, C10.1, P3.1, U1.59 (VCCIO2), U1.80 (VCCIO2), U1.94 (VCCIO2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, CON1.2, P2.2, P4.1, P4.43, P4.44, P5.2, P5.43, P5.44, P6.2, P6.10, P7.1, R1.2 (K), U1.10 (GNDIO), U1.11 (GNDINT), U1.32 (GNDIO), U1.46 (GNDIO), U1.60 (GNDIO), U1.65 (GNDINT), U1.79 (GNDIO), U1.93 (GNDIO), U2.1 (GND), X1.2 (GND)
VCC: C1.1, CON1.1, P2.1, U2.3 (VI)

Notes on the sheet:
Use Jumper P1 to drive custom voltage for for Bank 1 I/O's
Use Jumper P3 to drive custom voltage for Bank 1 I/O's
P2 is driven with VCC from ATTAMI's J3
CON1 drives VCC when the board is used without an ATTAMI
P7 is driven from ATTAMI's J3 It carries SPI signals

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
Board: 2 copper layers, 58.4 x 38.1 mm, 25 parts (16 on the bottom side), 89 nets.

## KiCad design epm240tami.kicad_pcb

Parts:
C1, C2: CP1; C_0603
C3, C4, C5, C6, C7, C8, C9, C10: C; C_0603
CON1: BARREL_JACK
P1, P3: CONN_01X03; Pin_Header_Straight_1x03
P2: CONN_01X02; Socket_Strip_Straight_1x02
P4, P5: CONN_02X22; Pin_Header_Straight_2x22
P6: JTAG; Pin_Header_Straight_2x05
P7: CONN_01X07; Socket_Strip_Straight_1x07
R1: 1K; R_0805
R2, R3, R4: 10K; R_0805
U1: EPM240T100C5N; TQFP-100_14x14mm_Pitch0.5mm
U2: NCP1117ST33T3G; SOT-223
X1: 50MHz; crystal_FA238-TSX3225

Connections:
/CLK_CORE: P4.11, U1.12 (IO/GCLK0), X1.3 (OUT)
/DI: P5.31, P7.2, U1.58 (IO)
/DM: P4.18, P7.5, U1.2 (IO)
/DO: P5.32, P7.3, U1.61 (IO)
/DP1: P4.17, P7.6, U1.3 (IO)
/DP2: P4.16, P7.7, U1.4 (IO)
/IO1: P4.19, U1.1 (IO)
/IO5: P4.15, U1.5 (IO)
/IO6: P4.14, U1.6 (IO)
/IO7: P4.13, U1.7 (IO)
/IO8: P4.12, U1.8 (IO)
/IO14: P4.10, U1.14 (IO/GCLK1)
/IO15: P4.9, U1.15 (IO)
/IO16: P4.8, U1.16 (IO)
/IO17: P4.7, U1.17 (IO)
/IO18: P4.6, U1.18 (IO)
/IO19: P4.5, U1.19 (IO)
/IO20: P4.4, U1.20 (IO)
/IO21: P4.3, U1.21 (IO)
/IO26: P5.3, U1.26 (IO)
/IO27: P5.4, U1.27 (IO)
/IO28: P5.5, U1.28 (IO)
/IO29: P5.6, U1.29 (IO)
/IO30: P5.7, U1.30 (IO)
/IO33: P5.8, U1.33 (IO)
/IO34: P5.9, U1.34 (IO)
/IO35: P5.10, U1.35 (IO)
/IO36: P5.11, U1.36 (IO)
/IO37: P5.12, U1.37 (IO)
/IO38: P5.13, U1.38 (IO)
/IO39: P5.14, U1.39 (IO)
/IO40: P5.15, U1.40 (IO)
/IO41: P5.16, U1.41 (IO)
/IO42: P5.17, U1.42 (IO)
/IO43: P5.18, U1.43 (IO/DEV_OE)
/IO44: P5.19, U1.44 (IO/DEV_CLRn)
/IO47: P5.20, U1.47 (IO)
/IO48: P5.21, U1.48 (IO)
/IO49: P5.22, U1.49 (IO)
/IO50: P5.23, U1.50 (IO)
/IO51: P5.24, U1.51 (IO)
/IO52: P5.25, U1.52 (IO)
/IO53: P5.26, U1.53 (IO)
/IO54: P5.27, U1.54 (IO)
/IO55: P5.28, U1.55 (IO)
/IO56: P5.29, U1.56 (IO)
/IO57: P5.30, U1.57 (IO)
/IO62: P5.33, P7.4, U1.62 (IO/GCLK2)
/IO64: P5.34, U1.64 (IO/GCLK3)
/IO66: P5.35, U1.66 (IO)
/IO67: P5.36, U1.67 (IO)
/IO68: P5.37, U1.68 (IO)
/IO69: P5.38, U1.69 (IO)
/IO70: P5.39, U1.70 (IO)
/IO71: P5.40, U1.71 (IO)
/IO72: P5.41, U1.72 (IO)
/IO73: P5.42, U1.73 (IO)
/IO74: P4.42, U1.74 (IO)
/IO75: P4.41, U1.75 (IO)
/IO76: P4.40, U1.76 (IO)
/IO77: P4.39, U1.77 (IO)
/IO78: P4.38, U1.78 (IO)
/IO81: P4.37, U1.81 (IO)
/IO82: P4.36, U1.82 (IO)
/IO83: P4.35, U1.83 (IO)
/IO84: P4.34, U1.84 (IO)
/IO85: P4.33, U1.85 (IO)
/IO86: P4.32, U1.86 (IO)
/IO87: P4.31, U1.87 (IO)
/IO88: P4.30, U1.88 (IO)
/IO89: P4.29, U1.89 (IO)
/IO90: P4.28, U1.90 (IO)
/IO91: P4.27, U1.91 (IO)
/IO92: P4.26, U1.92 (IO)
/IO95: P4.25, U1.95 (IO)
/IO96: P4.24, U1.96 (IO)
/IO97: P4.23, U1.97 (IO)
/IO98: P4.22, U1.98 (IO)
/IO99: P4.21, U1.99 (IO)
/IO100: P4.20, U1.100 (IO)
/TCK: P6.1, R1.1 (A), U1.24 (TCK)
/TDI: P6.9, R2.2 (K), U1.23 (TDI)
/TDO: P6.3, R4.2 (K), U1.25 (TDO)
/TMS: P6.5, R3.2 (K), U1.22 (TMS)
/VCCIO1: C5.1, C6.1, C7.1, P1.2, U1.9 (VCCIO1), U1.31 (VCCIO1), U1.45 (VCCIO1)
/VCCIO2: C8.1, C9.1, C10.1, P3.2, U1.59 (VCCIO2), U1.80 (VCCIO2), U1.94 (VCCIO2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, CON1.2, CON1.3, P2.2, P4.1, P4.43, P4.44, P5.1, P5.43, P5.44, P6.2, P6.10, P7.1, R1.2 (K), U1.10 (GNDIO), U1.11 (GNDINT), U1.32 (GNDIO), U1.46 (GNDIO), U1.60 (GNDIO), U1.65 (GNDINT), U1.79 (GNDIO), U1.93 (GNDIO), U2.1 (GND), X1.2 (GND)
VCC: C1.1, CON1.1, P1.1, P2.1, P3.1, U2.3 (VI)

Notes on the sheet:
Jumper P1 selects the voltage source (5V/3.3V) for Bank 1 I/O's
Jumper P3 selects the voltage source (5V/3.3V) for Bank 1 I/O's
P2 is driven with VCC from ATTAMI's J3
CON1 drives VCC when the board is used without an ATTAMI
P7 is driven from ATTAMI's J3 It carries SPI signals

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
Board: 2 copper layers, 63.5 x 41.9 mm, 25 parts (16 on the bottom side), 89 nets.

## Commit log

2015-04-12 Initial files for epm240tami
2015-04-13 After routing with TopoR and slightly compacting the component layout
2015-04-14 snapshot before changing layout
2015-04-16 Cloned current project into *_n, where n indicates "narrow". In this version, the EPM240 is parallel to the pins and not diagonal.
2015-04-17 Updated schematic and moved DI/DO around to reduce routing due to new placement. Added PDF file
2015-04-17 Added README.md
